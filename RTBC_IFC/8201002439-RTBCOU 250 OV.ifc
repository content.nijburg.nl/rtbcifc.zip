Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: ee58df14-0892-46dd-90a7-e70538a9e90b, NumberOfSaves: 30]
File name: Project Number
Time: 2024-01-17T14:00:12+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, InPort_1660674_1
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: NLRS_57_AIR_UN_swirl diffuser rtbc LT_sacs:250, NLRS_57_AIR_UN_swirl diffuser rtbc LT_sacs:250:1660674
In: Default
Type - Description: Round flanged Swirl supply grill, Type RTBC; PredefinedType: DIFFUSER; Material: RAL9010, Sendzimir verzinkt
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_swirl diffuser rtbc LT_sacs; SACS_Base_Index: 1
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - T: 1 mm
Type - General - Lookup_Article_Data: RTBC_Article_Data; Lookup_Grill_Factors: Grill_Selection_Factors; SACS_Article_Data: RTBC_Data; SACS_Revised_ by: J. Feeke; SACS_Revision_Date: 04-04-2022; SACS_Revision_Number: 3.19.02
Type - Identity Data - Assembly Code: 57.00; Cost: 0; Description: Round flanged Swirl supply grill, Type RTBC; Manufacturer: Solid Air Climate Solutions; Model: RTBC; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 04-04-2022; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.19.02; NLRS_C_description: Round flanged Swirl supply grill, Type RTBC; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Type Name: 250; URL: https://solid-air.nl/producten/solid-air-plafondroosters-rtbc-rrbc/
Type - Mechanical - Flow - Max Flow: 80 dm3/s; Min Flow: 20 dm3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.00 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 250; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_swirl diffuser rtbc LT_sacs; Family and Type: NLRS_57_AIR_UN_swirl diffuser rtbc LT_sacs: 250; Type: 250; Type Id: 1660653
Model Properties - SACS_Color_Ral: yes; SACS_Connector_Top: no; SACS_Lined_Plenum: no; SACS_Option_1: RTBCO; SACS_Option_2: OU OV; SACS_Oval_Connector: yes; SACS_Standard_Color: yes
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - NLRS_M_c01_diameter: 125 mm; SACS_Plenum_Height: 200 mm; Size: 125ø; Volume: 0.000429136 m3
Identity Data - Mark: 7150; NLRS_C_materiaal_kleur: Ral 9010; NLRS_C_model: RTBCOU 250 OV; SACS_Article_Code: 8201002439; SACS_Gross_Cost: 45; SACS_Price_Date: 01-02-2022
Materials and Finishes - SACS_Color: Ral 9010; SACS_Face_Color: RAL9010; SACS_Lining_Thickness: 0 mm
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_dBA: 28; SACS_Max_Ploss: 35 Pa; SACS_Primairy_Air_Temperature: 15 C; SACS_Room_Temperature: 25 C; System Classification: Supply Air
Mechanical - Flow - Flow: 0 dm3/s; NLRS_M_c01_debiet: 0 dm3/s; SACS_Cooling_Capacity: 0 W; SACS_Heating_Capacity: 0 W; SACS_Lp_dBA: 0; SACS_Throw: 0 mm
Phasing - Phase Created: New Construction
Visibility - SACS_Arrows_and_Throw_Enabled: yes; SACS_Throw_Visible: yes; SACS_Warning_Disable: no
